# Keil uVision project USBD_Audio_Speaker.uvproj, settings and files
target USBD_Audios_Speaker (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: USBD_Audio_Speaker
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\NUC505Series\Include;..\Library\StdDriver\inc;..\Hardware;..\Audio;..\USB
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\scatter.ld
  link misc: --datacompressor=off --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/NUC505Series/Source/ARM/: startup_NUC505Series.s
    ../Library/Device/Nuvoton/NUC505Series/Source/: system_NUC505Series.c
  group Library
    ../Library/StdDriver/src/: retarget.c clk.c uart.c sys.c i2c.c i2s.c usbd.c gpio.c timer.c
  group User
    ../: main.c
  group Hardware
    ../Hardware/: Hardware.c
  group Audio
    ../USB/: usbd_audio_play.c
  group USB
    ../USB/: USBLib.c usbd_audio_10.c usbd_audio_20.c descriptors_10.c descriptors_20.c USBD_IRQHandler_10.c USBD_IRQHandler_20.c UAC_Init_10.c UAC_Init_20.c UAC_ClassOUT_10.c UAC_ClassOUT_20.c UAC_ClassRequest_10.c UAC_ClassRequest_20.c UAC_SetInterface_10.c UAC_SetInterface_20.c
